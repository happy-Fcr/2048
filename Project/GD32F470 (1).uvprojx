# Keil uVision project GD32F470 (1).uvprojx, settings and files
target GD32F470 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F470 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=2
  c include: ..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\User;..\Hardware\led;..\Hardware\usart;..\Hardware\key;..\Hardware\timer;..\User;..\Project;..\Project;C:\Users\20646\Downloads\game-ex-base-code-master\1驱动屏幕\Hardware\Lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: systick.c main.c gd32f4xx_it.c sys.c
    ./: game.h font8x16.h
    C:/Users/20646/Desktop/Game/Firmware/GD32F4xx_standard_peripheral/Source/: game2048.c game2048.h
    C:/Users/20646/Downloads/game-ex-base-code-master/1驱动屏幕/Hardware/Lcd/: Lcd.c Lcd.h Spi4.c Spi4.h
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Hardware
    ../Hardware/led/: bsp_led.c
    ../Hardware/usart/: bsp_usart.c
    ../Hardware/key/: bsp_key.c
    ../Hardware/timer/: bsp_basic_timer.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_misc.c gd32f4xx_syscfg.c gd32f4xx_exti.c gd32f4xx_timer.c
    C:/Users/20646/Desktop/Game/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_spi.c
  group Doc
    ../Doc/: readme.txt
